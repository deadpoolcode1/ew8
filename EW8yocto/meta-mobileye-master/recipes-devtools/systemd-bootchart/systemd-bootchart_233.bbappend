SUMMARY = "Modify configuration"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://bootchart.conf;subdir=git/src"
