require canquick_${PV}.bb

SRC_URI += "file://modify_version_x.x.1.diff"
#SRC_URI += "file://modify_version_x.x.2.diff"
#SRC_URI += "file://modify_version_x.x.3.diff"





